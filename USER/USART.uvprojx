# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\SYSTEM\mb_usart;..\FWLIB\inc;..\HARDWARE\timer;..\HARDWARE\CRC16;..\HARDWARE\MDBS_FUNC;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\SYSTEM\freertos_demo;..\HARDWARE\EXTI;..\HARDWARE\MAC;..\HARDWARE\LORA;..\HARDWARE\ROUTING;..\HARDWARE\FLASH;..\HARDWARE\EC20;..\HARDWARE\IIC;..\HARDWARE\EEPROM;..\HARDWARE\INA226;..\HARDWARE\SHT45;..\HARDWARE\BMP280;..\HARDWARE\IWDG;..\HARDWARE\MYRTC;..\HARDWARE\EWDG;..\HARDWARE\EEPROM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c adaptive_report.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/timer/: timer.c
    ../HARDWARE/CRC16/: crc16.c
    ../HARDWARE/MDBS_FUNC/: mdbs_func.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/MAC/: mac.c
    ../HARDWARE/LORA/: lora.c
    ../HARDWARE/ROUTING/: routing.c tree_node.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/EC20/: EC20.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/EEPROM/: eeprom_24c02.c
    ../HARDWARE/INA226/: ina226.c
    ../HARDWARE/SHT45/: sht45.c
    ../HARDWARE/BMP280/: bmp280.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/MYRTC/: myrtc.c
    ../HARDWARE/EWDG/: ewdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/mb_usart/: Mb_usart.c
    ../SYSTEM/freertos_demo/: freertos_demo.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_rng.c stm32f4xx_flash.c stm32f4xx_iwdg.c stm32f4xx_rtc.c stm32f4xx_pwr.c
  group FreeRTOS_CORE
    ../FreeRTOS/: list.c queue.c tasks.c timers.c event_groups.c croutine.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group README
    ../: readme.txt
